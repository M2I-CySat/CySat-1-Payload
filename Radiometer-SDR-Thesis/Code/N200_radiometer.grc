<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>N200_TPR</value></param>
<param><key>author</key><value>Matthew E Nelson</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Total power radiometer connecting to a N200 SDR</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Total Power Radiometer - N200</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>GUI_samp_rate</value></param>
<param><key>choices</key><value>[1e6,2e6,5e6,10e6,25e6]</value></param>
<param><key>value</key><value>10e6</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Sample Rate (BW)</value></param>
<param><key>labels</key><value>['1 MHz','2 MHz','5 MHz','10 MHz','25 MHz']</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>add_noise</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>3,3,1,1</value></param>
<param><key>label</key><value>Noise Source</value></param>
<param><key>labels</key><value>['Off','On']</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>calib_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>4.0755e3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Calibration value 1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>calib_2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-342.774</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Calibration value 2</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dc_gain</value></param>
<param><key>choices</key><value>[1, 10, 100, 1000, 10000]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>DC Gain</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>det_rate</value></param>
<param><key>value</key><value>int(20.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftrate</value></param>
<param><key>value</key><value>int(samp_rate/fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_rate</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>frequency</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Center Frequency (Hz)</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>26</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>integ</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>2</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Integration Time (Seconds)</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>noise_amplitude</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>.01</value></param>
<param><key>notebook</key><value>Main, 0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"tpr_"</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>rec_button_iq</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Record I/Q Data</value></param>
<param><key>labels</key><value>['Stop','Start']</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>rec_button_tpr</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Record TPR Data</value></param>
<param><key>labels</key><value>['Stop','Start']</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile_kelvin</value></param>
<param><key>value</key><value>prefix+"kelvin" + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile_tpr</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(GUI_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scope_rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>spavg</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Spectral Averaging (Seconds)</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_data_fifo</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"spectrum_" + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>text_Device_addr</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>devid</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Device Address</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>text_USRP_Clock</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>clock</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,3,1,1</value></param>
<param><key>label</key><value>N200 Clock</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>text_deviceID</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>subdev</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>SubDev</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>text_samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>GUI_samp_rate</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Samp rate</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>labels</key><value>['N200 Control Panel','TPR Measurements']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>TPR</key>
<param><key>id</key><value>TPR_0</value></param>
<param><key>integ</key><value>integ</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>det_rate</key><value>det_rate</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>open</key><value>rec_button_tpr</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>open</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>open</key><value>rec_button_iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>calib_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>recfile_kelvin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>prefix+"iq_raw" + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>recfile_tpr</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>spec_data_fifo</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>int(det_rate/file_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>fftrate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>dc_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>calib_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_peak_detector_xb</key>
<param><key>id</key><value>blocks_peak_detector_xb_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>type</key><value>float</value></param>
<param><key>look_ahead</key><value>10</value></param>
<param><key>threshold_factor_fall</key><value>0.40</value></param>
<param><key>threshold_factor_rise</key><value>0.25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Clock rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>USRP Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.4125e9</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>uri</key><value>localhost</value></param>
<param><key>frequency</key><value>int(freq)</value></param>
<param><key>manual_gain1</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>15000000</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>False</value></param>
<param><key>samplerate</key><value>int(GUI_samp_rate)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0/float(spavg*fftrate)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>frame_rate</key><value>fftrate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Source Signal</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>Raw IQ File Storage</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>Calibration Values</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>DC gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subdev</value></param>
<param><key>label</key><value>USRP Subdevice ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>A:0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>samp_rate</key><value>GUI_samp_rate</value></param>
<param><key>title</key><value>Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>factor</key><value>1</value></param>
<param><key>max_value</key><value>400</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>scope_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Calibrated Temperature</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>Kelvin</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>avg_alpha</key><value>.01</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>6</value></param>
<param><key>factor</key><value>1</value></param>
<param><key>max_value</key><value>.2</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>scope_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Raw Power level</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value></value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_2</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>1</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>GUI_samp_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>Units</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_2</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>2</value></param>
<param><key>t_scale</key><value>100</value></param>
<param><key>title</key><value>Total Power</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_STRIPCHART</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.1</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>power level</value></param>
</block>
<connection><source_block_id>TPR_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blocks_file_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_2</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blks2_valve_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>wxgui_numbersink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_peak_detector_xb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_3</source_block_id><sink_block_id>blocks_file_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector_xb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>TPR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>blks2_valve_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_keep_one_in_n_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
