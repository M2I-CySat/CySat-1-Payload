<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AD9361_TPR_nogui</value></param>
<param><key>author</key><value>Matthew E Nelson</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Total power radiometer connecting to a AD9361 SDR</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Total Power Radiometer - AD9361</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>det_rate</value></param>
<param><key>value</key><value>int(20.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_rate</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(sample_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tpr_file</value></param>
<param><key>value</key><value>prefix +  "tpr " + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tpr_kelvin_file</value></param>
<param><key>value</key><value>prefix +  "tpr_kelvin " + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RF_bandwidth</value></param>
<param><key>label</key><value>RF bandwidth (Hz)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15000000</value></param>
</block>
<block>
<key>TPR</key>
<param><key>id</key><value>TPR_0</value></param>
<param><key>integ</key><value>integ</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>det_rate</key><value>det_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>calib_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/analog/Documents/sdr_dev/data/tpr_kelvin_shay.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>tpr_raw_shay.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>int(det_rate/file_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>dc_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>calib_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>calib_1</value></param>
<param><key>label</key><value>Calibration value 1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>830.54</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>calib_2</value></param>
<param><key>label</key><value>Calibration value 2</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-460.45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dc_gain</value></param>
<param><key>label</key><value>DC Gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.4125e9</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>uri</key><value>localhost</value></param>
<param><key>frequency</key><value>int(freq)</value></param>
<param><key>manual_gain1</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>RF_bandwidth</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>False</value></param>
<param><key>samplerate</key><value>int(sample_rate)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>integ</value></param>
<param><key>label</key><value>Integration Time (seconds)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Source Signal</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>Calibration Values</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>DC gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/analog/Documents/sdr_dev/data/</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>Raw</value></param>
<param><key>update_time</key><value>.5</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>300</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>Calibrated</value></param>
<param><key>update_time</key><value>.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>Sample Rate (BW)</value></param>
<param><key>value</key><value>15e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spavg</value></param>
<param><key>label</key><value>Spectral Averaging (Seconds)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>TPR_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>TPR_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>TPR_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
